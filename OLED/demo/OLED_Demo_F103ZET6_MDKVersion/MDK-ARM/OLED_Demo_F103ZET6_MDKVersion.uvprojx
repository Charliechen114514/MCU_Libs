# Keil uVision project OLED_Demo_F103ZET6_MDKVersion.uvprojx, settings and files
target OLED_Demo_F103ZET6_MDKVersion (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: OLED_Demo_F103ZET6_MDKVersion +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,SSD1309,USE_SOFTSPI_PROTOCOL,STM32F1
  c misc: --diag_suppress=1,1295,188,186
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: ascii6x8.source.c ascii8x16.source.c CCGraphic_Arc.c CCGraphic_Base.c CCGraphic_Circle.c CCGraphic_device_adapter.c CCGraphic_device_oled_adapter.c CCGraphic_Ellipse.c CCGraphic_Frame.c CCGraphic_Image.c CCGraphic_Line.c CCGraphic_Menu.c CCGraphic_MenuItem.c CCGraphic_Point.c CCGraphic_Rectangle.c CCGraphic_Size.c CCGraphic_TextConfig.c CCGraphic_TextEdit.c CCGraphic_TextItem.c CCGraphic_Triangle.c CCGraphic_Utils.c CCGraphicWidget_Base.c gpio.c graphic_test_base.c graphic_test_device.c graphic_test_widget.c graphoc_test_components.c hard_iic.c hard_iic__fastsetup.c hard_spi.c hard_spi__fastsetup.c main.c oled_base_driver_ssd1306.c oled_base_driver_ssd1309.c oled_test.c oled_test_gard_spi.c oled_test_hard_iic.c oled_test_soft_iic.c oled_test_soft_spi.c simple_text.c soft_iic.c soft_iic_fastsetup.c soft_spi.c soft_spi_fast_setup.c stm32f1xx_hal_msp.c stm32f1xx_it.c test_all.c test_image.c test_image_temp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
